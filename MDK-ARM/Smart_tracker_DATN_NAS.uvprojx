# Keil uVision project Smart_tracker_DATN_NAS.uvprojx, settings and files
target Smart_tracker_DATN_NAS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431CCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Smart_tracker_DATN_NAS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Lib/BSP;../Lib/Driver_Custom;../Lib/Services/StorageManager;../Lib/Task;../Lib/Utils;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Lib/Services/IMU;../Config;../Lib/Services/Modem;../Lib/Services/System
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group BSP
    ../Lib/BSP/: bsp_spi.c bsp_spi.h bsp_uart.c bsp_uart.h bsp_adc.c bsp_adc.h
  group Task
    ../Lib/Task/: w25q32_task.h w25q32_task.c icm42605_task.h icm42605_task.c atgm336h_task.c atgm336h_task.h battery_task.c battery_task.h sim_task.c sim_task.h system_manager_task.c system_manager_task.h power_task.c power_task.h
  group Driver_Custom
    ../Lib/Driver_Custom/: w25q32.c w25q32.h icm42605.h icm42605.c atgm336h.c atgm336h.h sim_a7670c.c sim_a7670c.h
  group Utils
    ../Lib/Utils/: log.h log.c ring_buffer.c ring_buffer.h
  group Service
    ../Lib/Services/StorageManager/: storage_manager.c storage_manager.h
    ../Lib/Services/IMU/: imu_service.c
    ../Lib/Services/Modem/: mqtt_service.c mqtt_service.h sms_service.c sms_service.h
    ../Lib/Services/System/: system_service.h system_service.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Conifg
    ../Config/: secrets.h secrets_template.h
software components: CMSIS:CORE 4.3.0
